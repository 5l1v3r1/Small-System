# Keil uVision project small_system.uvproj, settings and files
target Small System (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: small_system +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\libraries\CMSIS\CM3\CoreSupport;.\libraries\STM32F10x_StdPeriph_Driver\inc;.\libraries;.\hal;.\kernel;.\kernel\kernel_ui;.\kernel\memory_poor;.\kernel\thread_poor;.\kernel\file_poor;.\kernel\file_poor\fatfs;.\kernel\graphics_library;.\kernel\kernel_expand;.\application;.\application\application_executer;.\application\application_local\telephone;.\application\application_local\alarm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group stm32 core
    ./libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ./libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stm32 library
    ./libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group stm32 configration
    ./libraries/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group HAL code
    ./hal/: system_main.c system_interrupt.c power_api.c led_api.c beep_api.c key_api.c sram_api.c flash_inside_api.c flash_outside_api.c sd_api.c uart_api.c lcd_api.c time_api.c delay.c sys.c
    ./hal/flash_device/: flash_device_api.c
    ./hal/sd_device/: sdio_sdcard.c
    ./hal/lcd_device/: lcd_device_api.c lcd_device_touch.c 24cxx.c iic.c
    ./hal/rtc_device/: rtc_device_api.c
  group kernel core
    ./kernel/: kernel_notice.c kernel_main.c
    ./kernel/kernel_ui/: kernel_ui_api.c
    ./kernel/thread_poor/: thread_main.c
  group kernel memory
    ./kernel/memory_poor/: malloc.c
  group kernel file
    ./kernel/file_poor/: file_operate.c
    ./kernel/file_poor/fatfs/src/: ff.c diskio.c
    ./kernel/file_poor/fatfs/src/option/: cc936.c
    ./kernel/file_poor/fatfs/exfuns/: fattester.c exfuns.c
  group kernel graphics
    ./kernel/graphics_library/: graphics_background.c graphics_bitmap.c graphics_font.c graphics_widget.c graphics_window.c
  group kernel expand
    ./kernel/kernel_expand/: kernel_expand_gsm.c
  group application desktop
    ./application/: system_desktop.c system_desktop_ui.c system_desktop_application_execute.c
  group application executer
    ./application/application_executer/: script_hoster.c script_resolve.c script_syntax.c
  group application telephone
    ./application/application_local/telephone/: telephone_ui.c
  group application alarm
    ./application/application_local/alarm/: alarm_ui.c
